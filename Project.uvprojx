# Keil uVision project Project.uvprojx, settings and files
target Worm7_Locked (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(64000000) ELITTLE
  output: Worm7_Locked +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,APP_VALVE_COUNT=7
  c misc: --no-multibyte-chars
  c include: .\User;.\Hardware;.\System;.\Library\HAL\Inc;.\Start\Device\Include;.\Start\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/Device/Source/Templates/arm/: startup_stm32f103xb.s
    ./Start/Device/Source/Templates/: system_stm32f1xx.c
  group Library
    ./Library/HAL/Src/: stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_uart.c
  group System
    ./System/: System.c
  group Hardware
    ./Hardware/: Board.c Serial.c
  group User
    ./User/: Command.c main.c Pneumatic.c Robot.c stm32f1xx_it.c
target Worm11_Locked (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: Worm11_Locked +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,APP_VALVE_COUNT=11
  c misc: --no-multibyte-chars
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
